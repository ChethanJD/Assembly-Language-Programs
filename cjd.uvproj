# Keil uVision project cjd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: cjd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BLCK_EXCH.asm BLCK_TANF.asm LARGST.asm SMLST.asm DESCND.asm ADD16BIT.asm SUB16.asm mul.asm DIV.asm UP_COUNT.asm DOWN_COUNT.asm CUBE.asm
