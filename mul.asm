ORG 00H
MOV A,20H
MOV B,40H
MUL AB
MOV 60H,A
MOV 61H,B

MOV A,20H
MOV B,41H
MUL AB
ADD A,61H
MOV 61H,A
MOV A,B
ADDC A,62H
MOV 62H,A

MOV A,21H
MOV B,40H
MUL AB
ADD A,61H
MOV 61H,A
MOV A,B
ADDC A,62H
MOV 62H,A

MOV A,#00
ADDC A,#00
MOV 63H,A
MOV A,21H
MOV B,41H
MUL AB
ADD A,62H
MOV 62H,A
MOV A,B
ADDC A,63H
MOV 63H,A
END